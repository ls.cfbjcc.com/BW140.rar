!  2-Port S-parameters saved by WinCal
! VAR MeasName=S-Parameters (CALIBRATED_DATA) read from VNA (N5244A)
! VAR MeasDate=11/21/2012 4:47:17 PM
! VAR NAME=128931
! VAR FILENAME=128931.S2P
! VAR DATE=11/21/2012 4:47:17 PM
! VAR PHYS_PORTS=1,2
# Hz S MA R 50
! Worked out from all points (weakly coupled two-port):
!   801 points, 100 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -39.13 dB at 25.74 GHz (marker M1); lowest = -88.2 dB at 772.8 MHz (marker M2)
!   lowest |S11| = -30.8 dB at 23.46 GHz (marker M3), VSWR 1.06, Z = 47.4 - j0.929 ohm
!   |S11| at or under -10 dB: 10.99 GHz to 11.45 GHz (458.3 MHz wide, 4.08 % of centre); 11.47 GHz to 17.76 GHz (6.293 GHz wide, 43.1 % of centre); 18.59 GHz to 25.47 GHz (6.887 GHz wide, 31.3 % of centre) (the widest 3 of 20)
!   |S22| runs from -4.7 to -0.4 dB; largest |S21 - S12| = 0.0038
!   the Smith chart shows 22.6 GHz to 24.28 GHz only
!   S11 on the Smith chart (normalised r, x): 22.6 GHz: 0.85, -0.04; 23.01 GHz: 0.98, -0.23; 24.28 GHz: 1.16, -0.44
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 MHz  -0.8  -57.6  -54.7  -0.5
! 772.8 MHz  -0.8  -88.2  -66.6  -0.6
! 1.072 GHz  -0.9  -64.5  -66.4  -0.7
! 1.446 GHz  -0.9  -55.1  -55.0  -0.7
! 1.931 GHz  -1.0  -60.4  -61.2  -0.5
! 2.38 GHz  -1.0  -64.4  -64.1  -0.5
! 5.108 GHz  -1.1  -58.7  -57.6  -0.5
! 10.08 GHz  -10.2  -48.6  -53.7  -0.6
! 11.5 GHz  -11.1  -52.6  -50.3  -0.7
! 12.43 GHz  -17.0  -52.4  -50.5  -0.7
! 13.82 GHz  -13.4  -53.1  -51.9  -0.8
! 14.64 GHz  -24.9  -50.5  -49.5  -0.7
! 15.05 GHz  -14.2  -50.2  -50.7  -0.8
! 15.57 GHz  -13.6  -49.3  -48.1  -0.8
! 20.06 GHz  -13.9  -49.2  -47.7  -0.9
! 22.6 GHz  -21.6  -44.4  -45.3  -1.1
! 23.01 GHz  -18.7  -43.6  -43.9  -1.2
! 23.46 GHz  -30.8  -43.5  -44.3  -1.2
! 24.28 GHz  -13.5  -41.8  -42.7  -1.4
! 25.03 GHz  -15.4  -41.7  -42.1  -1.5
! 25.74 GHz  -9.8  -39.1  -40.6  -1.7
! 30 GHz  -2.4  -43.8  -44.9  -4.7
